Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: LVI293.00.ifc
Time: 2023-12-12T12:24:20
Author: Misiek
Organization: Trimble
Written by: TrimBimToIFC ver 1.0
Made in: TrimBimToIFC ver 1.0
Authorization: IFC4 model

# IfcBuildingElementProxy (58)
Name
4 x Undefined | LVI293.01.01.01 - Description: LVI293.01.01.01:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.01.03 - Description: LVI293.01.01.03:1; ObjectType: SketchupComponentInstance
4 x Undefined | LVI293.01.01.04 - Description: LVI293.01.01.04:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.01.05 - Description: LVI293.01.01.05:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.01.06 - Description: LVI293.01.01.06:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.01.07 - Description: LVI293.01.01.07:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.01.08 - Description: LVI293.01.01.08:1; ObjectType: SketchupComponentInstance
24 x Undefined | LVI293.01.02.01 - Description: LVI293.01.02.01:1; ObjectType: SketchupComponentInstance
4 x Undefined | LVI293.01.02.02 - Description: LVI293.01.02.02:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.02.03 - Description: LVI293.01.02.03:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.02.05 - Description: LVI293.01.02.05:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.02.04 - Description: LVI293.01.02.04:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.03.01 - Description: LVI293.01.03.01:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.03.03 - Description: LVI293.01.03.03:1; ObjectType: SketchupComponentInstance
2 x Undefined | LVI293.01.03.02 - Description: LVI293.01.03.02:1; ObjectType: SketchupComponentInstance
